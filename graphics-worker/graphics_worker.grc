options:
  parameters:
    generate_options: no_gui
    id: graphics_worker
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: backend_host
  id: variable
  parameters:
    value: '"backend-controller"'
  states: {}
- name: calibration
  id: variable
  parameters:
    value: '-30'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: graphics_udp_port
  id: variable
  parameters:
    value: '9001'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: sdr_host
  id: variable
  parameters:
    value: '"sdr-server"'
  states: {}
- name: sdr_iq_port
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: skip
  id: variable
  parameters:
    value: '20'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: fft_size
    n: skip*fft_size
    offset: '0'
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: calibration
    n: '10'
    vlen: fft_size
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: float
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import socket

      class blk(gr.sync_block):
          """
          Sends FFT vectors via UDP.
          """
          def __init__(self, vector_len=2048, host="localhost", port=9001):
              gr.sync_block.__init__(
                  self,
                  name='UDP Vector Sender',
                  in_sig=[(np.float32, vector_len)],
                  out_sig=None
              )

              self.host = host
              self.port = port

              self.sock = socket.socket(socket.AF_INET, socket.SOCK_DGRAM)
              self.dest = (self.host, self.port)

          def work(self, input_items, output_items):
              in0 = input_items[0]
              n = len(in0)

              for v in in0:
                  try:
                      self.sock.sendto(v.tobytes(), self.dest)
                  except Exception:
                      pass

              return n
    host: backend_host
    port: graphics_udp_port
    vector_len: fft_size
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import yaml
  states: {}
- name: snippet_1
  id: snippet
  parameters:
    code: |-
      #CONFIG LOADER

      with open("/app/config.yaml", "r") as f:
          cfg = yaml.safe_load(f)

      self.cfg = cfg  # Make configuration available to all other blocks/snippets

      # Apply GRC variables (e.g., sample_rate, lo_freq, iio_uri)
      for key, val in cfg.items():

          setter_lower = f"set_{key.lower()}"
          if hasattr(self, setter_lower):
              getattr(self, setter_lower)(val)
              continue

          setter_original = f"set_{key}"
          if hasattr(self, setter_original):
              getattr(self, setter_original)(val)
    section: main_after_start
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: f"tcp://{sdr_host}:{sdr_iq_port}"
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_nlog10_ff_0, '0', epy_block_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_1, '0', blocks_nlog10_ff_0, '0']
- [blocks_vector_to_stream_0, '0', virtual_sink_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [virtual_source_0, '0', blocks_keep_m_in_n_0, '0']
- [zeromq_sub_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
