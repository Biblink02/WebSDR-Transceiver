options:
  parameters:
    generate_options: no_gui
    id: graphics_worker
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: fft_size
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: is_active
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: skip
  id: variable
  parameters:
    value: '20'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: fft_size
    n: skip*fft_size
    offset: '0'
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fft_size
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: float
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import socket
      import os

      class blk(gr.sync_block):
          """
          Sends FFT vectors via UDP only if active=True.
          """
          def __init__(self, vector_len=2048, active=True):
              gr.sync_block.__init__(
                  self,
                  name='UDP Vector Sender',
                  in_sig=[(np.float32, vector_len)],
                  out_sig=None
              )

              self.active = active

              self.host = os.environ.get("BACKEND_HOST", "backend-controller")
              try:
                  self.port = int(os.environ.get("BACKEND_GRAPHICS_PORT", "9001"))
              except ValueError:
                  self.port = 9001

              self.sock = socket.socket(socket.AF_INET, socket.SOCK_DGRAM)
              self.dest = (self.host, self.port)

          def work(self, input_items, output_items):
              in0 = input_items[0]
              n_items = len(in0)

              if not self.active:
                  return n_items

              for vector in in0:
                  try:
                      self.sock.sendto(vector.tobytes(), self.dest)
                  except Exception:
                      pass

              return n_items
    active: is_active
    vector_len: fft_size
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import threading, zmq, json
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      def control_loop(flowgraph):
          ctx = zmq.Context()
          sock = ctx.socket(zmq.PULL)
          sock.bind("tcp://0.0.0.0:5001")
          print("[Graphics] Control Thread listening on 5001")

          while True:
              try:
                  msg = sock.recv_json()
                  cmd = msg.get("cmd")

                  if cmd == "start":
                      if not flowgraph.get_is_active():
                          print("[Graphics] Activating Stream")
                          flowgraph.set_is_active(True)

                  elif cmd == "stop":
                      print("[Graphics] Going IDLE (Stopped)")
                      flowgraph.set_is_active(False)

              except Exception as e:
                  print(f"[Graphics] Error: {e}")

      t = threading.Thread(target=control_loop, args=(self,))
      t.daemon = True
      t.start()
    section: main_after_init
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://sdr-server:5000
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_nlog10_ff_0, '0', epy_block_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_1, '0', blocks_nlog10_ff_0, '0']
- [blocks_vector_to_stream_0, '0', virtual_sink_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [virtual_source_0, '0', blocks_keep_m_in_n_0, '0']
- [zeromq_sub_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
