options:
  parameters:
    generate_options: no_gui
    id: audio_worker
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: '15000'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '40'
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: is_active
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '50000'
    max_dev: 5e3
    quad_rate: '50000'
    tau: '75e-6'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import socket
      import os

      class blk(gr.sync_block):
          """
          UDP sender that can be muted via the 'active' parameter.
          """
          def __init__(self, active=True):
              gr.sync_block.__init__(
                  self,
                  name='UDP Sender with Header',
                  in_sig=[np.float32],
                  out_sig=None
              )
              
              self.active = active

              self.pod_name = os.environ.get("POD_NAME", "worker-manual")
              self.host = os.environ.get("BACKEND_HOST", "backend-controller")
              try:
                  self.port = int(os.environ.get("BACKEND_AUDIO_PORT", "9002"))
              except ValueError:
                  self.port = 9002
                  
              self.sock = socket.socket(socket.AF_INET, socket.SOCK_DGRAM)
              self.dest = (self.host, self.port)
              self.header = f"{self.pod_name}:".encode('utf-8')

          def work(self, input_items, output_items):
              in0 = input_items[0]
              n_items = len(in0)
              
              if not self.active:
                  return n_items

              if n_items > 0:
                  try:
                      audio_payload = in0.tobytes()
                      self.sock.sendto(self.header + audio_payload, self.dest)
                  except Exception:
                      pass
                      
              return n_items
    active: is_active
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-freq_offset'
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, bandwidth/2, 5000)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import threading, zmq, json
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '48'
    type: fff
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      # --- Function that receives the flowgraph as an argument ---
      def control_loop(flowgraph):
          ctx = zmq.Context()
          sock = ctx.socket(zmq.PULL)
          sock.bind("tcp://0.0.0.0:5001")
          print("[Control] Thread started on port 5001")

          while True:
              try:
                  msg = sock.recv_json()
                  cmd = msg.get("cmd")

                  if cmd == "tune":
                      flowgraph.set_is_active(True)
                      if "freq_offset" in msg:
                          flowgraph.set_freq_offset(float(msg["freq_offset"]))
                      if "bw" in msg:
                          flowgraph.set_bandwidth(float(msg["bw"]))

                  elif cmd == "idle":
                      print("[Control] Going IDLE")
                      flowgraph.set_is_active(False)
                      flowgraph.set_freq_offset(0)
                      flowgraph.set_bandwidth(1000)

              except Exception as e:
                  print(f"[Control] Error: {e}")

      # --- THREAD STARTUP ---
      # NOTE: Here we use 'self' because GRC calls the snippet with the current
      # block instance named 'self'.
      t = threading.Thread(target=control_loop, args=(self,))
      t.daemon = True
      t.start()
    section: main_after_init
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://sdr-server:5000
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_nbfm_rx_0, '0', rational_resampler_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_nbfm_rx_0, '0']
- [rational_resampler_xxx_0, '0', epy_block_0, '0']
- [zeromq_sub_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
