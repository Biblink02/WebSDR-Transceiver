options:
  parameters:
    author: Mihir_vedant
    category: Custom
    generate_options: qt_gui
    id: PlutoSDR_reciever_UDP
    output_language: python
    title: SDR -> FFT frames-> UDP Socket PDU
  states: {}

blocks:
- name: fft_len
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: pkt_tag
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/fft_len
    type: float
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: packet_len
    packet_len: fft_len
    type: float
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: packet_len
    packet_len: fft_len
    type: complex
  states: {}
- name: c2mag
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_len
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '1024'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '2400000000'
    gain1: '''slow_attack'''
    len_tag_key: ''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '3500'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 172.28.0.101
    mtu: '10000'
    port: '8000'
    tcp_no_delay: 'True'
    type: UDP_CLIENT
  states: {}
- name: network_socket_pdu_0_0
  id: network_socket_pdu
  parameters:
    host: 172.28.0.101
    mtu: '10000'
    port: '8005'
    tcp_no_delay: 'True'
    type: UDP_CLIENT
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: float
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: s2v
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_len
    type: complex
  states: {}
- name: v2s
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_len
    type: float
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [c2mag, '0', v2s, '0']
- [fft_vxx_0, '0', c2mag, '0']
- [iio_pluto_source_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [iio_pluto_source_0, '0', qtgui_sink_x_0, '0']
- [low_pass_filter_0, '0', s2v, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, network_socket_pdu_0, pdus]
- [pdu_tagged_stream_to_pdu_0_0, pdus, network_socket_pdu_0_0, pdus]
- [s2v, '0', fft_vxx_0, '0']
- [v2s, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
