options:
  parameters:
    author: 'Mihir Vedant '
    description: SSB_demo
    generate_options: qt_gui
    id: SSB
    output_language: python
    title: SSB Transmitter
  states: {}

blocks:
- name: Transmit_Range
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,3
    label: Transmit_range
    start: '2448650000'
    step: '10000'
    stop: '2451350000'
    value: '2450000000'
  states: {}
- name: band_pass_filter_taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: '3500'
    low_cutoff_freq: '300'
    samp_rate: samp_rate
    type: complex_band_pass
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    comment: 0,0,1,3
    gui_hint: 0,0,1,3
    label: Mic gain (dB)
    start: '-60'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sb_sel_t
  id: variable_qtgui_chooser
  parameters:
    comment: 2,0,1,1
    gui_hint: 2,0,1,1
    label: Transmit Sideband
    label0: Upper
    label1: Lower
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: 10**(gain/20)
    high_cutoff_freq: '3500'
    low_cutoff_freq: '300'
    samp_rate: samp_rate
    type: fir_filter_fcc
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: sb_sel_t
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_swapiq_0
  id: blocks_swapiq
  parameters: {}
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '2000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: Transmit_Range
    samplerate: '1000000'
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: 4,0,1,3
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,0,1,3
    type: complex
    ymax: '1'
    ymin: '-100'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    comment: 6,0,1,3
    fc: '0.0'
    fftsize: '1024'
    gui_hint: 6,0,1,3
    showports: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '48000'
    interp: '1000000'
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '35'
  states: {}

connections:
- [audio_source_0, '0', band_pass_filter_0, '0']
- [band_pass_filter_0, '0', blocks_selector_0, '0']
- [band_pass_filter_0, '0', blocks_swapiq_0, '0']
- [blocks_selector_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_selector_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_selector_0, '0', rational_resampler_xxx_0, '0']
- [blocks_selector_0, '0', virtual_sink_0, '0']
- [blocks_swapiq_0, '0', blocks_selector_0, '1']
- [rational_resampler_xxx_0, '0', iio_pluto_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
