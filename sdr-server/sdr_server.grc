options:
  parameters:
    generate_options: no_gui
    id: sdr_server
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: SDR_CONTROL_PORT
  id: variable
  parameters:
    value: '5001'
  states: {}
- name: SDR_HOST
  id: variable
  parameters:
    value: '"sdr-server"'
  states: {}
- name: SDR_IQ_PORT
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: buffer_size
  id: variable
  parameters:
    value: '32768'
  states: {}
- name: iio_uri
  id: variable
  parameters:
    value: '"ip:192.168.2.1"'
  states: {}
- name: is_active
  id: variable
  parameters:
    value: '1'
  states: {}
- name: lo_freq
  id: variable
  parameters:
    value: '2450000000'
  states: {}
- name: rf_bandwidth
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import zmq

      class blk(gr.sync_block):
          """
          Replaces zeromq_pub_sink. Sends I/Q data only when active=True.
          """
          def __init__(self, active=True, iq_port=5000):
              gr.sync_block.__init__(
                  self,
                  name='ZMQ Conditional Publisher',
                  in_sig=[np.complex64],
                  out_sig=None
              )
              self.active = active
              self.port = iq_port

              self.context = zmq.Context()
              self.socket = self.context.socket(zmq.PUB)
              self.socket.bind(f"tcp://0.0.0.0:{self.port}")

          def set_active(self, active):
              """Setter used by the control thread."""
              self.active = active

          def work(self, input_items, output_items):
              in0 = input_items[0]
              n = len(in0)

              if not self.active:
                  return n

              if n > 0:
                  try:
                      self.socket.send(in0.tobytes())
                  except Exception as e:
                      print(f"[SDR-ZMQ] Error sending data: {e}")

              return n
    active: is_active
    iq_port: SDR_IQ_PORT
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: rf_bandwidth
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: lo_freq
    gain1: '''slow_attack'''
    len_tag_key: ''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: iio_uri
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import yaml, threading, zmq
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      with open("/app/config.yaml", "r") as f:
          cfg = yaml.safe_load(f)

      self.cfg = cfg

      for key, val in cfg.items():
          setter_lower = f"set_{key.lower()}"
          if hasattr(self, setter_lower):
              getattr(self, setter_lower)(val)
              continue

          setter_original = f"set_{key}"
          if hasattr(self, setter_original):
              getattr(self, setter_original)(val)

      def control_loop(flowgraph):
          ctx = zmq.Context()
          control_port = flowgraph.cfg["SDR_CONTROL_PORT"]

          sock = ctx.socket(zmq.PULL)
          sock.bind(f"tcp://0.0.0.0:{control_port}")
          print(f"[SDR] Control Thread listening on {control_port}")

          zmq_pub_block = flowgraph.epy_block_0

          while True:
              try:
                  msg = sock.recv_json()
                  cmd = msg.get("cmd")

                  if cmd == "start":
                      print("[SDR] Activating I/Q Stream (Start)")
                      zmq_pub_block.set_active(True)

                  elif cmd == "stop":
                      print("[SDR] Pausing I/Q Stream (Stop)")
                      zmq_pub_block.set_active(False)

              except Exception as e:
                  print(f"[SDR] Control Error: {e}")

      t = threading.Thread(target=control_loop, args=(self,))
      t.daemon = True
      t.start()
    section: main_after_init
  states: {}

connections:
- [iio_pluto_source_0, '0', epy_block_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
